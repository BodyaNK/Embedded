# Keil uVision project lab6_test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab6_test
  AfterMake: fromelf.exe Objects\lab6_test.axf --bin --output BINOUTPUT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\lab6_test.sct
  group Source Group 1
    ./: main.c
  group Icons
    ./: Icons.c Unicode.c IconsDef.h IconsRes.h IconsList.h unicode.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
